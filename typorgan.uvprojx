# Keil uVision project typorgan.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F722RETx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.15.1
  cpu: IRAM(0x20010000,0x30000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x80000) IROM2(0x00200000,0x80000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: typorgan
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0x200000 size 0x80000
  memory RVCT9: RAM 0x20010000 size 0x30000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group App
    ./src/: draw.c event_handler.c lfo.c menu.c midi.c notes.c page.c param.c scope.c ui.c view.c voice.c main.cpp page_osc.c page_env.c page_lfo.c page_strct.c page_midi.c
  group Driver
    ./src/: ad.c da.c flash.c led.c sw.c system.c timer.c uart.c disp.c
  group Resource
    ./rsc/: font.c wave.c
software components: CMSIS:CORE 5.5.0, Device:Startup 1.2.5
